# Repository modeler/c64-dodgypla

File README.md:

# PLA replacement for the C64

## XCPLA

The XCPLA is a replacement for the PLA in older versions of the Commodore 64. It is my rendition of the [DodgyPLA by desater](https://github.com/desaster/c64-dodgypla) (see below). While the original version is made for self-etching, the XCPLA layout is optimized for professional board manufacturers.

More information can be found in my [blog post](https://www.hackup.net/2019/05/the-xcpla-yet-another-pla-replacement/).

In hindsight, it would have been better to create a new repository for the XCPLA. But somehow I failed to do so in time, so here we are.

There is no warranty whatsoever. **USE AT YOUR OWN RISK!**.

## DodgyPLA

Based on the work by skoe:

[https://bitbucket.org/skoe/pla](1)
[http://skoe.de/docs/c64-dissected/pla/c64_pla_dissected_a4ds.pdf](2)

This design uses the Xilinx XC9536XL, which has 5V tolerant inputs essential
for operation with the Commodore 64.

As opposed to skoe's design, the required CASRAM delay is implemented in
Verilog instead of using additional components.

This project includes:

* A Xilinx ISE project written in Verilog for Xilinx XC9536XL
* A KiCad project including a board designed for home etching

## KiCad design kicad/dodgypla.kicad_pcb

Parts:
C1, C2: 3.3uF; C_0805
C3, C4, C5: 0.1uF; C_0805
J1: PLA_Conn; DIP-28_W15.24mm_Socket
J2: JTAG; Pin_Header_Straight_2x04_Pitch2.54mm
U1: AMS1117; SOT-223-3_TabPin2
U2: XC9536XL-10VQ44C; LQFP-44_10x10mm_Pitch0.8mm

Connections:
+5V: C1.1, J1.28, U1.3 (Vin)
/JTAG_TCK: J2.1, U2.11 (TCK)
/JTAG_TDI: J2.7, U2.9 (TDI)
/JTAG_TDO: J2.5, U2.24 (TDO)
/JTAG_TMS: J2.3, U2.10 (TMS)
/PLA_A12: J1.27, U2.23 (IO2-13)
/PLA_A13: J1.2, U2.28 (IO2-11)
/PLA_A14: J1.3, U2.29 (IO2-10)
/PLA_A15: J1.4, U2.30 (IO2-9)
/PLA_AEC: J1.25, U2.22 (IO2-14)
/PLA_BA: J1.26, U2.19 (IO2-17)
/PLA_BASIC: J1.17, U2.13 (IO1-14)
/PLA_CAS: J1.9, U2.42 (IO1-4)
/PLA_CASRAM: J1.18, U2.12 (IO1-13)
/PLA_CHAREN: J1.6, U2.27 (IO2-12)
/PLA_CHAROM: J1.15, U2.7 (IO1-11)
/PLA_EXROM: J1.23, U2.21 (IO2-15)
/PLA_FE: J1.1
/PLA_GAME: J1.22, U2.18 (IO1-17)
/PLA_GRW: J1.13, U2.6 (IO1-10)
/PLA_HIRAM: J1.7, U2.37 (IO2-4)
/PLA_IO: J1.12, U2.5 (IO1-9)
/PLA_KERNAL: J1.16, U2.8 (IO1-12)
/PLA_LORAM: J1.8, U2.41 (IO1-2)
/PLA_OE: J1.19
/PLA_ROMH: J1.10, U2.2 (IO1-6)
/PLA_ROML: J1.11, U2.3 (IO1-8)
/PLA_RW: J1.24, U2.20 (IO2-16)
/PLA_VA12: J1.20, U2.14 (IO1-15)
/PLA_VA13: J1.21, U2.16 (IO1-16)
/PLA_VA14: J1.5, U2.31 (IO2-8)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, J1.14, J2.8, U1.1 (GND/ADJ), U2.4 (GND), U2.17 (GND), U2.25 (GND)

Notes on the sheet:
Pin naming based on: http://www.zimmers.net/cbmpics/cbm/c64/pla.txt
Pinout based on: http://www.nightfallcrew.com/18/11/2009/xilink-cpld-xc9536-replacement-pla-for-commodore-64/
JTAG

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
Board: 2 copper layers, 19.0 x 36.8 mm, 9 parts (0 on the bottom side), 31 nets.

## Commit log

2019-04-02 Converting to two-layer board for PCB manufacturing.
2019-05-31 Fixed symbol library.
2019-05-31 Added compiled firmware to repo.
2019-05-31 Updated README.
2019-05-31 Updated license.
2019-05-31 Added PDF schematics.
2019-05-31 Added Gerber files.
2019-06-04 Optimized JTAG header.
2019-08-19 Updated compiled firmware.
2019-09-17 Added missing bypass caps.
2019-09-20 Preparing for revision 2.
2019-10-14 Use LQFP44 standard footprint.
2019-10-14 Smaller THT pads and solder mask clearance.
2020-03-13 Added Gerber export for rev.2
2020-04-28 Add delay to all output ports taken from neatPLA, see https://github.com/desaster/c64-dodgypla/issues/4.
